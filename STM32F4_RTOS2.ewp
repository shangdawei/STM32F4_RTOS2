# IAR project STM32F4_RTOS2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __DEBUG__; STM32F40XX=1; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: Source\Application; Source\MCU; Source\RTOS2
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Linker\stm32f40x_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F40XX=1; HSE_VALUE=8000000
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: Linker\stm32f40x_flash.icf
  group Source/Application
    Source/Application/: BSP.c BSP.h main.c RTE_Components.h RTX_Config.c rtx_config.h
  group Source/MCU
    Source/MCU/: startup_stm32f40x.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
    Source/RTOS2/: user_svc.c
  group Source/RTOS2
    Source/RTOS2/: cmsis_os2.h core_cm.h core_cm_Override.h irq_cm3.s irq_cm4f.s rtx_delay.c rtx_evflags.c rtx_kernel.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_os.h rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
