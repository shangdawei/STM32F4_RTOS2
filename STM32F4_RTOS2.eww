<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32F4_RTOS2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


